# Keil uVision project direct_test_mode_s132.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 S132 NRF52 SOFTDEVICE_PRESENT
  c include: .;config;..\components\drivers_nrf\config;..\components\ble\ble_dtm;..\components\drivers_nrf\hal;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain;..\components\drivers_nrf\delay;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\libraries\util;..\components\drivers_nrf\twi_master;..\components\libraries\trace
  asm define: BSP_DEFINES_ONLY NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF52 SOFTDEVICE_PRESENT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c bq25120.c hal_twim.c
  group Documentation
    ./: Abstract.txt license.txt
  group nRF_BLE
    ../components/ble/ble_dtm/: ble_dtm.c
  group nRF_Drivers
    ../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
