# Keil uVision project HRM 1153 onboard processing.uvprojx, settings and files
target mixedNuts (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: mixedNuts +hex
  c flags: Optim=4 OneElfS=1
  c define: S132 NRF_LOG_USES_RTT=1 ENABLE_DEBUG_LOG_SUPPORT=1 BSP_DEFINES_ONLY NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 CONFIG_NFCT_PINS_AS_GPIOS CONFIG_GPIO_AS_PINRESET NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET BOARD_PCA10036 NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23
  c misc: --c99
  c include: .;config;..\app;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\ble\common;..\components\drivers_nrf\hal;..\components\libraries\uart;..\components\libraries\button;..\components\ble\ble_services\ble_nus;..\components\ble\ble_advertising;..\components\device;..\components\toolchain;..\components\libraries\util;..\components\libraries\fifo;..\components\drivers_nrf\uart;..\components\drivers_nrf\config;..\components\drivers_nrf\common;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\twi_master;..\components\softdevice\common\softdevice_handler;..\components\libraries\timer;..\components\drivers_nrf\delay;..\components\libraries\trace;..\components\drivers_nrf\pstorage;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_dis;.\battery;.\data_log;.\heart_rate;.\led;.\motion;.\motion\imu;.\motion\imu\invensense;.\led;..\components\drivers_nrf\saadc;..\components\drivers_nrf\hal;..\components\drivers_nrf\ppi;..\components\libraries\pwm;..\components\drivers_nrf\timer;..\components\drivers_nrf\rtc;..\components\drivers_nrf\clock;..\components\ble\device_manager;..\components\drivers_ext\segger_rtt;..\components\libraries\bootloader_dfu;..\components\ble\ble_services\ble_dfu;..\components\drivers_nrf\wdt;..\components\libraries\fstorage;..\components\libraries\experimental_section_vars;..\components\libraries\fstorage\config;..\components\drivers_nrf\pstorage\config;..\components\ble\device_manager\config;..\components\drivers_nrf\spi_master
  asm define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52_PAN_12 S132 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_NFCT_PINS_AS_GPIOS
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20001fe8 size 0xe018
  group Application
    ./: main.c
    ./: comms.c manufacture_test.c timing.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_services/ble_nus/: ble_nus.c
    ../components/ble/ble_services/ble_dis/: ble_dis.c
    ../components/ble/ble_services/ble_bas/: ble_vsp_bas.c
    ../components/ble/device_manager/: vsp_device_manager_peripheral.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/pstorage/: pstorage.c
    ../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../components/drivers_nrf/hal/: nrf_saadc.c
    ../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    ../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c SEGGER_RTT.c
    ../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c app_util_platform.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/trace/: app_trace.c
    ../components/libraries/uart/: retarget.c app_uart_fifo.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group IMU
    ./motion/imu/stmicro/: lsm6ds3_i2c.c lsm6ds3.c
    ./motion/imu/: hal_imu.c hal_twim.c
  group Motion
    ./motion/: data_crunch.c step_detect_1.c step_detect_2.c
  group Datalog
    ./data_log/: reports.c mem_manager.c hal_nvm.c int_flash.c
    ./data_log/External_Storage/: hal_spim.c spiflash.c ext_flash.c
  group LED
    ./led/: led.c
  group Battery
    ./battery/: battery.c bq25120.c
  group HRM
    ./heart_rate/: drv_si115x.c hrm_detect.c
target flash_s132_nrf52_2.0.0-7.alpha_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: mcgenesis +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF_LOG_USES_UART=1 ENABLE_DEBUG_LOG_SUPPORT=1 NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52_PAN_12 S132 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_NFCT_PINS_AS_GPIOS
  c misc: --c99
  c include: config;..\mcgenesis;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\ble\common;..\components\drivers_nrf\hal;..\components\libraries\uart;..\components\libraries\button;..\components\ble\ble_services\ble_nus;..\components\ble\ble_advertising;..\components\device;..\components\toolchain;..\components\libraries\util;..\components\libraries\fifo;..\components\drivers_nrf\uart;..\components\drivers_nrf\config;..\components\drivers_nrf\common;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\twi_master;..\components\softdevice\common\softdevice_handler;..\components\libraries\timer;..\components\drivers_nrf\delay;..\components\libraries\trace;..\components\drivers_nrf\pstorage;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_dis;.\battery;.\data_log;.\led;.\motion;.\motion\imu;.\motion\imu\invensense;.\led;..\components\drivers_nrf\saadc;..\components\drivers_nrf\hal;..\components\drivers_nrf\ppi;..\components\libraries\pwm;..\components\drivers_nrf\timer;..\components\drivers_nrf\rtc;..\components\drivers_nrf\clock;..\components\ble\device_manager;..\components\drivers_ext\segger_rtt;..\components\ble\ble_services\ble_dfu
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.0.1, Device:Startup 8.17.0
