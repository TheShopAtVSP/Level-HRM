# Keil uVision project mcg_bootloader.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: mcg_bootloader +hex
  c flags: Optim=4 OneElfS=1
  c define: S132 NRF_LOG_USES_RTT=0 ENABLE_DEBUG_LOG_SUPPORT=0 BSP_DEFINES_ONLY NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 CONFIG_NFCT_PINS_AS_GPIOS CONFIG_GPIO_AS_PINRESET NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET BOARD_PCA10036 NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23
  c misc: --c99
  c include: config;..\components\ble\ble_services\ble_dfu;..\components\ble\common;..\components\drivers_nrf\common;..\components\drivers_nrf\config;..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\pstorage;..\components\libraries\bootloader_dfu;..\components\libraries\bootloader_dfu\ble_transport;..\components\libraries\crc16;..\components\libraries\hci;..\components\libraries\scheduler;..\components\libraries\timer;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain;..\app\led;..\app;..\components\libraries\trace;..\components\drivers_ext\segger_rtt
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23 NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET BOARD_PCA10036 NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 S132 BSP_DEFINES_ONLY NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x7a000 size 0x4000
  memory RVCT9: RAM 0x20002c00 size 0x5380
  memory RVCT10: RAM 0x20007f80 size 0x80
  group Application
    ./: dfu_ble_svc.c main.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_weak.c nrf_log.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../components/libraries/bootloader_dfu/: bootloader.c bootloader_settings.c bootloader_util.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble_vsp.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/hci/: hci_mem_pool.c
    ../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../components/libraries/trace/: app_trace.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group LED
    ../app/led/: led.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.1
